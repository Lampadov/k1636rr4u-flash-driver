# Keil uVision project RR4.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.2.2.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: HelloWorld +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .;.\RTE\Device\MDR1986BE1T
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c FLASH_test.c
software components: Device:Startup 2.2.0, Drivers:EBC 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:SSP 2.0.3, Drivers:TIMER 2.1.0
